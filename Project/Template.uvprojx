# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Inc;..\FATFS\Inc;..\Interrupt\Inc;..\FWLIB\inc;..\FWLIB\StartUp;..\FWLIB\SystemInc;..\SDCard\Inc;..\Drives\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Project
    ./: main.c
  group System
    ../Drives/Src/: rcc.c usart.c
  group StartUp
    ../FWLIB/StartUp/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/Src/: core_cm3.c
    ../FWLIB/SystemSrc/: system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_flash.c
  group Interrupt
    ../Interrupt/Src/: stm32f10x_it.c
  group SDIO
    ../SDCard/Src/: sdio_sd.c
  group FATFS
    ../FATFS/Src/: diskio.c ff.c ffsystem.c ffunicode.c
